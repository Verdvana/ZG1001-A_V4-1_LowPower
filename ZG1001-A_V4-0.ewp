# IAR project ZG1001-A_V4-0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: D:\SXZG_mplab\zg1000systemLDCall\newparam20k\ZG1001-A_V4-1; D:\SXZG_mplab\zg1000systemLDCall\newparam20k\ZG1001-A_V4-1\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ZG1001-A_V4-0.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: E:\MCU\STM8\ZG1001-A_V4-1-5.2.1; E:\MCU\STM8\ZG1001-A_V4-1-5.2.1\VS2013-ZG1001-A_V4-0; E:\MCU\STM8\ZG1001-A_V4-1-5.2.1\VS2013-ZG1001-A_V4-0\ZG1001-A_V4-0; E:\MCU\STM8\ZG1001-A_V4-1-5.2.1\Libraries\STM8L15x_StdPeriph_Driver\inc; E:\MCU\STM8\ZG1001-A_V4-1-5.2.1\Libraries\STM8L15x_StdPeriph_Driver
  ILINK.IlinkOutputFile: ZG1001-A_V4-0.out
  group LIB/INC
    Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_TIM2.h stm8l15x_TIM3.h stm8l15x_tim4.h stm8l15x_TIM5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group LIB/SRC
    Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group USER/INC
    ./: delay.h main.h mcudriver.h radio_config_si4438.h si4438driver.h stm8l15x_conf.h stm8l15x_it.h stm8l_discovery_lcd.h uart1.h
  group USER/SRC
    ./: delay.c main.c mcudriver.c si4438driver.c stm8l15x_it.c stm8l_discovery_lcd.c uart1.c
